Commit message: gray to grey

File: description/colours.xacro (robot description, xacro)
@@ -26,5 +26,5 @@
         <color rgba="1 0 1 1"/>
     </material>
-    <material name="gray">
+    <material name="grey">
         <color rgba="0.5 0.5 0.5 1"/>
     </material>
